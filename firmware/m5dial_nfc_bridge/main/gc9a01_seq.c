#include "gc9a01_seq.h"

/* cmd, nbytes, delay_lo, delay_hi, payload... */
static const uint8_t SEQ[] = {
    0x36, 1, 0, 0, 0x08,
    0x3A, 1, 0, 0, 0x05,
    0x21, 0, 0, 0,
    0xEF, 0, 0, 0,
    0xEB, 1, 0, 0, 0x14,
    0xFE, 0, 0, 0,
    0xEF, 0, 0, 0,
    0xEB, 1, 0, 0, 0x14,
    0x84, 1, 0, 0, 0x40,
    0x85, 1, 0, 0, 0xFF,
    0x86, 1, 0, 0, 0xFF,
    0x87, 1, 0, 0, 0xFF,
    0x8E, 1, 0, 0, 0xFF,
    0x8F, 1, 0, 0, 0xFF,
    0x88, 1, 0, 0, 0x0A,
    0x89, 1, 0, 0, 0x21,
    0x8A, 1, 0, 0, 0x00,
    0x8B, 1, 0, 0, 0x80,
    0x8C, 1, 0, 0, 0x01,
    0x8D, 1, 0, 0, 0x01,
    0xB6, 2, 0, 0, 0x00, 0x20,
    0x90, 4, 0, 0, 0x08, 0x08, 0x08, 0x08,
    0xBD, 1, 0, 0, 0x06,
    0xBC, 1, 0, 0, 0x00,
    0xFF, 3, 0, 0, 0x60, 0x01, 0x04,
    0xC3, 1, 0, 0, 0x13,
    0xC4, 1, 0, 0, 0x13,
    0xC9, 1, 0, 0, 0x22,
    0xBE, 1, 0, 0, 0x11,
    0xE1, 2, 0, 0, 0x10, 0x0E,
    0xDF, 3, 0, 0, 0x21, 0x0c, 0x02,
    0xF0, 6, 0, 0, 0x45, 0x09, 0x08, 0x08, 0x26, 0x2A,
    0xF1, 6, 0, 0, 0x43, 0x70, 0x72, 0x36, 0x37, 0x6F,
    0xF2, 6, 0, 0, 0x45, 0x09, 0x08, 0x08, 0x26, 0x2A,
    0xF3, 6, 0, 0, 0x43, 0x70, 0x72, 0x36, 0x37, 0x6F,
    0xED, 2, 0, 0, 0x1B, 0x0B,
    0xAE, 1, 0, 0, 0x77,
    0xCD, 1, 0, 0, 0x63,
    0x70, 9, 0, 0, 0x07, 0x07, 0x04, 0x0E, 0x0F, 0x09, 0x07, 0x08, 0x03,
    0xE8, 1, 0, 0, 0x34,
    0x62, 12, 0, 0, 0x18, 0x0D, 0x71, 0xED, 0x70, 0x70, 0x18, 0x0F, 0x71, 0xEF, 0x70, 0x70,
    0x63, 12, 0, 0, 0x18, 0x11, 0x71, 0xF1, 0x70, 0x70, 0x18, 0x13, 0x71, 0xF3, 0x70, 0x70,
    0x64, 7, 0, 0, 0x28, 0x29, 0xF1, 0x01, 0xF1, 0x00, 0x07,
    0x66, 10, 0, 0, 0x3C, 0x00, 0xCD, 0x67, 0x45, 0x45, 0x10, 0x00, 0x00, 0x00,
    0x67, 10, 0, 0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x54, 0x10, 0x32, 0x98,
    0x74, 7, 0, 0, 0x10, 0x68, 0x80, 0x00, 0x00, 0x4E, 0x00,
    0x98, 2, 0, 0, 0x3e, 0x07,
    0x35, 1, 0, 0, 0x00,
    0x11, 0, 120, 0,
    0x29, 0, 20, 0,
};

int gc9a01_walk(int (*cb)(uint8_t cmd, const uint8_t *data, uint8_t n,
                          uint16_t delay_ms, void *ctx),
                void *ctx)
{
    const uint8_t *p = SEQ;
    const uint8_t *end = SEQ + sizeof SEQ;
    while (p + 4 <= end) {
        uint8_t cmd = p[0];
        uint8_t n = p[1];
        uint16_t delay = (uint16_t)p[2] | ((uint16_t)p[3] << 8);
        p += 4;
        if (p + n > end) return -1;
        if (cb && cb(cmd, p, n, delay, ctx)) return -2;
        p += n;
    }
    return p == end ? 0 : -1;
}

int gc9_window_bytes(int x0, int y0, int x1, int y1)
{
    if (x0 < 0 || y0 < 0 || x1 > 239 || y1 > 239 || x1 < x0 || y1 < y0)
        return -1;
    return (x1 - x0 + 1) * (y1 - y0 + 1) * 2;
}

struct need {
    int sleep_out, display_on, madctl, pixfmt, invon, nop, bad;
};

static int check_cb(uint8_t cmd, const uint8_t *data, uint8_t n, uint16_t delay, void *ctx)
{
    struct need *s = ctx;
    (void)delay;
    if (cmd == 0x00) s->nop = 1;
    if (n > 16) s->bad = 1;
    if (cmd == 0x11) s->sleep_out = 1;
    if (cmd == 0x29) s->display_on = 1;
    if (cmd == 0x21) s->invon = 1;
    if (cmd == 0x36 && n == 1) s->madctl = 1;
    if (cmd == 0x3A && n == 1 && data && data[0] == 0x05) s->pixfmt = 1;
    return 0;
}

int gc9a01_sequence_ok(void)
{
    struct need s;
    s.sleep_out = s.display_on = s.madctl = s.pixfmt = s.invon = s.nop = s.bad = 0;
    if (gc9a01_walk(check_cb, &s) != 0) return 0;
    return s.sleep_out && s.display_on && s.madctl && s.pixfmt && s.invon
        && !s.nop && !s.bad;
}
